options:
  parameters:
    author: chuan li
    generate_options: qt_gui
    id: hop_tx
    output_language: python
    title: Freqency Hopping Transmitter
  states: {}

blocks:
- name: M_order
  id: variable
  parameters:
    value: '4'
  states: {}
- name: cnt_dir
  id: variable
  parameters:
    value: '''/home/lc/桌面/gnuradio_proj/oot_module/'''
  states: {}
- name: constellation_psk
  id: variable_constellation
  parameters:
    const_points: '[1+1j, -1+1j, 1-1j, -1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: (0,1,2,3)
    type: calcdist
  states: {state: disabled}
- name: hop_rate
  id: variable
  parameters:
    value: '20'
  states: {}
- name: interp_factor
  id: variable
  parameters:
    value: '256'
  states: {}
- name: num_sample1hop
  id: variable
  parameters:
    value: calc_vlen_bb_pskmod(hop_rate)
  states: {}
- name: num_sym1hop
  id: variable
  parameters:
    value: calc_vlen_slot_frame(hop_rate)
  states: {}
- name: raw_sync_word
  id: variable
  parameters:
    value: np.fromfile(cnt_dir+'head_sample/'+'sync_word_hop'+str(hop_rate)+'_psk'+str(M_order), dtype=np.complex64)
  states: {state: disabled}
- name: rotated_sync_word
  id: variable
  parameters:
    value: raw_sync_word*(0.707106781186547524+1j*0.707106781186547524)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '2457600'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: transmit power gain
    min_len: '100'
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.06'
    gain: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/lc/psk_wave.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lc/psk_wave.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    comment: 存储同步头
    file: cnt_dir+'head_sample/'+'sync_word_hop'+str(hop_rate)+'_psk'+str(M_order)
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    comment: 存储发送比特
    file: cnt_dir+'frame_idxs/'+'idxs_hop'+str(hop_rate)+'_psk'+str(M_order)
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: '''demod_bits_hop''+str(hop_rate)+''_psk''+str(M_order)'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: cnt_dir+"/head_sample/sync_word_hop20_psk2"
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 32768*2
    type: complex
  states: {state: disabled}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: calc_head_len_9600(hop_rate)
    type: complex
  states: {state: disabled}
- name: blocks_head_1_0
  id: blocks_head
  parameters:
    num_items: '1'
    type: int
    vlen: num_sym1hop
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_int_to_float_1
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"rx_time"'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 2.4e3
    type: int
  states: {state: disabled}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 9.6e3
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_sym1hop
    type: int
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_sample1hop
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_sample1hop*interp_factor
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_sample1hop*interp_factor
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: num_sample1hop
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_sym1hop
    type: int
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_psk
  states: {state: disabled}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '5'
    sps: '4'
    symbols: 2*rotated_sync_word
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: M_order
    w: '0.01'
  states: {state: disabled}
- name: freq_hopping_bb_pskmod_0
  id: freq_hopping_bb_pskmod
  parameters:
    Ksa_ch: '4'
    M_order: M_order
    comment: 基带调制
    hop_rate: hop_rate
  states: {}
- name: freq_hopping_bb_pskmod_0_0
  id: freq_hopping_bb_pskmod
  parameters:
    Ksa_ch: '4'
    M_order: M_order
    comment: 基带调制
    hop_rate: hop_rate
  states: {state: disabled}
- name: freq_hopping_frame_recover_0
  id: freq_hopping_frame_recover
  parameters:
    frame_len: calc_vlen_slot_frame(hop_rate)
  states: {state: disabled}
- name: freq_hopping_hop_demod_0
  id: freq_hopping_hop_demod
  parameters:
    bw_hop: 1e6
    ch_sep: 3e3
    freq_carrier: 500e3
    fsa_hop: samp_rate
    hop_rate: hop_rate
  states: {state: disabled}
- name: freq_hopping_hop_interp_0
  id: freq_hopping_hop_interp
  parameters:
    comment: 上采样
    interp_fac: interp_factor
    vlen_in: num_sample1hop
  states: {}
- name: freq_hopping_hop_mod_0
  id: freq_hopping_hop_mod
  parameters:
    bw_hop: 1e6
    ch_sep: 3e3
    comment: 跳频调制
    freq_carrier: 500e3
    fsa_hop: samp_rate
    hop_rate: hop_rate
    vlen: num_sample1hop*interp_factor
  states: {}
- name: freq_hopping_ser_measurement_0
  id: freq_hopping_ser_measurement
  parameters:
    filename: /home/lc/桌面/gnuradio_proj/oot_module/frame_idxs/idxs_hop20_psk4
  states: {state: disabled}
- name: freq_hopping_slot_frame_0
  id: freq_hopping_slot_frame
  parameters:
    M_order: M_order
    comment: 逐跳组帧
    hop_rate: hop_rate
    info_seed: '12345'
  states: {}
- name: freq_hopping_slot_frame_0_0
  id: freq_hopping_slot_frame
  parameters:
    M_order: M_order
    comment: 逐跳组帧
    hop_rate: hop_rate
    info_seed: '12345'
  states: {state: disabled}
- name: freq_hopping_slot_frame_0_1
  id: freq_hopping_slot_frame
  parameters:
    M_order: M_order
    comment: 逐跳组帧
    hop_rate: hop_rate
    info_seed: '12345'
  states: {state: disabled}
- name: freq_hopping_symbol_recover_0
  id: freq_hopping_symbol_recover
  parameters:
    sps: '4'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    size: 65536*2
    srate: samp_rate
    type: complex
    update_time: '0.2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '65536'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '65536'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '65536'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '4096'
    srate: samp_rate/interp_factor
    type: float
    ymax: '300'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    size: '2048'
    srate: samp_rate/interp_factor
    type: complex
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate/interp_factor/4
    type: float
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_0_0_2_0
  id: qtgui_time_sink_x
  parameters:
    size: '128'
    srate: samp_rate/interp_factor/120
    type: float
    update_time: '0.1'
    ymax: '0.5'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '100'
    srate: 9.6e3
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '32'
    srate: '2400'
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '-40'
    int_min: '-120'
    type: complex
    update_time: '0.05'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '-40'
    int_min: '-120'
    type: complex
    update_time: '0.05'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '-40'
    int_min: '-120'
    type: complex
    update_time: '0.05'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '256'
    fbw: '0.005'
    interp: '1'
    type: ccf
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 70e6
    gain0: '12'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 70e6
    comment: '"serial=326C056"'
    dev_addr: '"serial=326C056"'
    gain0: tx_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 70e6
    comment: '"serial=326C08D"'
    dc_offs_enb0: auto
    dev_addr: '"serial=326C08D"'
    gain0: '0'
    iq_imbal_enb0: auto
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc2_xx_0, '0', digital_corr_est_cc_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0_0_0_2, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_1_0, '0']
- [blocks_head_0, '0', freq_hopping_symbol_recover_0, '0']
- [blocks_head_1, '0', blocks_file_sink_1, '0']
- [blocks_head_1_0, '0', blocks_vector_to_stream_1_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_int_to_float_1, '0', blocks_float_to_char_0, '0']
- [blocks_int_to_float_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_head_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_int_to_float_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_throttle_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_throttle_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', blocks_throttle_0_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_int_to_float_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_2, '0']
- [digital_constellation_decoder_cb_0, '0', freq_hopping_ser_measurement_0, '0']
- [digital_corr_est_cc_0, '0', blocks_head_0, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [freq_hopping_bb_pskmod_0, '0', blocks_vector_to_stream_0_0, '0']
- [freq_hopping_bb_pskmod_0, '0', freq_hopping_hop_interp_0, '0']
- [freq_hopping_bb_pskmod_0_0, '0', blocks_vector_to_stream_1, '0']
- [freq_hopping_frame_recover_0, '0', digital_costas_loop_cc_0, '0']
- [freq_hopping_hop_demod_0, '0', blocks_file_sink_0_0, '0']
- [freq_hopping_hop_demod_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_hopping_hop_demod_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0, '0']
- [freq_hopping_hop_demod_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [freq_hopping_hop_demod_0, '0', rational_resampler_xxx_0, '0']
- [freq_hopping_hop_interp_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [freq_hopping_hop_interp_0, '0', freq_hopping_hop_mod_0, '0']
- [freq_hopping_hop_mod_0, '0', blocks_vector_to_stream_0_0_0_0, '0']
- [freq_hopping_ser_measurement_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0_0_0_2_0, '0']
- [freq_hopping_slot_frame_0, '0', blocks_vector_to_stream_0, '0']
- [freq_hopping_slot_frame_0, '0', freq_hopping_bb_pskmod_0, '0']
- [freq_hopping_slot_frame_0_0, '0', freq_hopping_bb_pskmod_0_0, '0']
- [freq_hopping_slot_frame_0_1, '0', blocks_head_1_0, '0']
- [freq_hopping_symbol_recover_0, '0', freq_hopping_frame_recover_0, '0']
- [freq_hopping_symbol_recover_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0_0_0_1, '0']
- [rational_resampler_xxx_0, '0', analog_agc2_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_tag_debug_0, '0']
- [uhd_usrp_source_0, '0', freq_hopping_hop_demod_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']

metadata:
  file_format: 1
